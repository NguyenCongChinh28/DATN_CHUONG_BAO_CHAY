# Keil uVision project Project.uvprojx, settings and files
target GD32E23x (6160000::V6.16::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: GD32E230,APP_BTN_MAX_BTN_SUPPORT=2,APP_MAX_LED_SUPPORT=2,DEBUG_RTT=1,DEBUG_UART=0
  c include: ..\..\Firmware\CMSIS;..\..\Utilities;..\;..\..\Utilities\LCD_Commom;..\..\Firmware\GD32E23x_standard_peripheral\Include;..\..\Firmware\CMSIS\GD\GD32E23x\Include;..\..\..\Gateway\esp32\components\app_btn\include;..\app_cli;..\..\..\Gateway\esp32\components\app_led_status\include;..\..\..\Gateway\esp32\components\app_spi\include;..\..\..\Gateway\esp32\components\lora\include;..\..\..\Gateway\esp32\components\systime\include;..\inc;..\..\..\Gateway\esp32\components\board_hw\include;..\..\..\Gateway\esp32\components\app_debug;..\SEGGER_RTT_V698b\RTT;..\lwrb\lwrb\src\include;..\board_hw\include;..\..\..\Gateway\esp32\components\lora_v2\include;..\..\..\Gateway\esp32\components\lora\porting;..\..\..\Gateway\esp32\components\lora_v2;..\..\..\Gateway\esp32\components\aithinker_ra01s\include;..\eeprom_emulation;..\..\port\app_btn;..\..\port\app_cli;..\..\port\app_crc\include;..\..\port\app_debug;..\..\port\app_led_status\include;..\..\port\app_spi;..\..\port\app_wdt;..\..\port\eeprom_emulation;..\..\port\lora\include;..\..\port\lwrb\lwrb\src\include;..\..\port\net_info\include;..\..\port\SEGGER_RTT_V762b\RTT;..\..\port\SEGGER_RTT_V762b\Config;..\..\port\systime\include;..\..\port\sx126x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../: gd32e23x_it.c main.c systick.c
    ../inc/: sdkconfig.h app_flash.h
    ../src/: app_flash.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group Peripherals
    ../../Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group Doc
    ../: readme.txt
  group port/spi
    ../board_hw/: board_hw.c
    ../board_hw/include/: board_hw.h
    ../../port/app_spi/: app_spi.c app_spi.h
  group ringbuff
    ../../port/lwrb/lwrb/src/lwrb/: lwrb.c
    ../../port/lwrb/lwrb/src/include/lwrb/: lwrb.h
  group port/app_cli
    ../../port/app_cli/: app_cli.c app_cli.h app_shell.c app_shell.h
  group port/SeggerRTT
    ../../port/SEGGER_RTT_V762b/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_printf.c
    ../../port/SEGGER_RTT_V762b/Config/: SEGGER_RTT_Conf.h
  group port/eeprom
    ../../port/eeprom_emulation/: eeprom.c eeprom.h
  group port/app_wdt
    ../../port/app_wdt/: app_wdt.c app_wdt.h
  group port/app_btn
    ../../port/app_btn/: app_btn.c app_btn.h
  group port/app_led_status
    ../../port/app_led_status/: app_led_status.c
    ../../port/app_led_status/include/: app_led_status.h
  group port/app_lora
    ../../port/lora/: app_lora.c lora_hal.c
    ../../port/lora/include/: app_lora.h lora_hal.h
  group port/systime
    ../../port/systime/: systime.c
    ../../port/systime/include/: systime.h
  group port/app_dbg
    ../../port/app_debug/: app_debug.c app_debug.h
  group port/main_app
    ../../port/main_app/: main_app.c
software components: CMSIS:CORE 5.0.2
