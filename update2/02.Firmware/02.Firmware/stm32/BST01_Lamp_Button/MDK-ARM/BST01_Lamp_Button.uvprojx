# Keil uVision project BST01_Lamp_Button.uvprojx, settings and files
target BST01_Lamp_Button (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: BST01_Lamp_Button +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../../../port/app_btn;../../../port/app_cli;../../../port/app_crc/include;../../../port/app_debug;../../../port/app_led_status/include;../../../port/app_spi;../../../port/app_wdt;../../../port/lora/include;../../../port/lora;../../../port/lwrb/lwrb/src/include;../../../port/main_app;../../../port/net_info/include;../../../port/SEGGER_RTT_V762b/RTT;../../../port/SEGGER_RTT_V762b/Config;../../../port/lora_stack/include;../../../port/systime/include;../../../port/board_hw/include;../../../port/app_flash
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c iwdg.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group port/spi
    ../../../port/app_spi/: app_spi.h
    ../Core/Src/: app_spi.c
  group port/ringbuff
    ../../../port/lwrb/lwrb/src/lwrb/: lwrb.c
    ../../../port/lwrb/lwrb/src/include/lwrb/: lwrb.h
  group port/app_cli
    ../../../port/app_cli/: app_cli.c app_cli.h app_shell.c app_shell.h
  group port/SeggerRTT
    ../../../port/SEGGER_RTT_V762b/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_printf.c
    ../../../port/SEGGER_RTT_V762b/Config/: SEGGER_RTT_Conf.h
  group port/lora_stack
    ../../../port/lora_stack/: app_lora.c crc.c lora_hal.c radio.c sx126x.c sx126x-board.c
    ../../../port/lora_stack/include/: app_lora.h crc.h lora_hal.h radio.h sx126x.h sx126x-board.h
  group port/app_wdt
    ../../../port/app_wdt/: app_wdt.h
    ../Core/Src/: app_wdt.c
  group port/app_btn
    ../../../port/app_btn/: app_btn.c app_btn.h
  group port/app_led_status
    ../../../port/app_led_status/: app_led_status.c
    ../../../port/app_led_status/include/: app_led_status.h
  group port/systime
    ../../../port/systime/: systime.c
    ../../../port/systime/include/: systime.h
  group port/app_dbg
    ../../../port/app_debug/: app_debug.c app_debug.h
  group port/main_app
    ../../../port/main_app/: main_app.c
  group port/board_hw
    ../../../port/board_hw/include/: board_hw.h
    ../../../port/board_hw/: board_hw.c
  group port/app_flash
    ../../../port/app_flash/: app_flash.h
    ../Core/Src/: app_flash.c
software components: CMSIS:CORE 4.3.0
