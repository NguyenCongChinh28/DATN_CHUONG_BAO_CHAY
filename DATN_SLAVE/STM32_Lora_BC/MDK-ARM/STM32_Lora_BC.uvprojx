# Keil uVision project STM32_Lora_BC.uvprojx, settings and files
target STM32_Lora_BC (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: STM32_Lora_BC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Components\App_spi\include;..\Components\App_debug;..\Components\Board_hw\include;..\Components\SEGGER_RTT_V762b\RTT;..\Components\SEGGER_RTT_V762b\Config;..\Components\App_wdt;..\Components\App_flash;..\Components\App_systime\include;..\Components\App_lora\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c iwdg.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group App_main
    ../Components/App_main/: app_main.c
  group App_spi
    ../Components/App_spi/: app_spi.c
  group App_debug
    ../Components/App_debug/: app_debug.c
  group Borad_hw
    ../Components/Board_hw/: board_hw.c
  group SeggerRTT
    ../Components/SEGGER_RTT_V762b/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group App_wdt
    ../Components/App_wdt/: app_wdt.c
  group App_flash
    ../Components/App_flash/: app_flash.c
  group App_systime
    ../Components/App_systime/: systime.c
  group App_lora
    ../Components/App_lora/: app_lora.c lora_hal.c crc.c radio.c sx126x.c sx126x-board.c
software components: CMSIS:CORE 5.6.0
